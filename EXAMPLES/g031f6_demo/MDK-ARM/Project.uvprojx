# Keil uVision project Project.uvprojx, settings and files
target Debug (6220000::V6.22::ARMCLANG)
  device: STM32G031F6Px STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0") CLOCK(8000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=6 v6LangP=9 wLevel=2
  c define: DEBUG
  c misc: -Wpedantic -Wextra
  c include: ../inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group src
    ../src/: main.c system_stm32g0xx.c
    ../MDK-ARM/: startup_stm32g031xx.s
target Release (ARM-ADS)
  device: STM32G031F6Px STMicroelectronics
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0+") CLOCK(8000000) ELITTLE
  output: Project +hex
  c flags: Optim=6 OneElfS=1 v6Lang=6 v6LangP=9 v6Lto=1 wLevel=2
  c define: NDEBUG
  c misc: -Wpedantic -Wextra
  c include: ../inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
